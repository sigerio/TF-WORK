# Keil uVision project xj_jc.uvprojx, settings and files
target XJ (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: xj_jc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F10X_HD
  c include: ..\CMSIS;..\GD32F10X\Include;..\TFSDK\config;..\TFSDK\hal;..\TFSDK\drv;..\TFSDK\framework;..\TFSDK\lib;..\USER;..\USER\LIB;..\USER\TOOL;..\USER\TASK;..\USER\MODULE;..\USER\MODULE\KEY;..\USER\MODULE\MOTO;..\USER\MODULE\module_ws2812;..\USER\MODULE\module_modbus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: system_gd32f10x.c gd32f10x.h system_gd32f10x.h
  group Startup
    ../CMSIS/GD/: startup_gd32f10x_hd.s
  group GD32F10X
    ../GD32F10X/Source/: gd32f10x_gpio.c gd32f10x_rcu.c gd32f10x_usart.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_exti.c gd32f10x_dma.c gd32f10x_misc.c gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_i2c.c gd32f10x_pmu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_wwdgt.c
  group TFSDK/HAL
    ../TFSDK/hal/gd32f10x/: tf_hal_gpio.c tf_hal_dma.c tf_hal_uart.c tf_hal_spi.c tf_hal_systick.c
  group TFSDK/DRV
    ../TFSDK/drv/: tf_drv_dma.c tf_drv_io.c tf_drv_uart.c tf_drv_spi.c tf_drv_systick.c
  group TFSDK/Config
    ../TFSDK/config/: tf_board_dma.c tf_board_io.c tf_board_uart.c tf_board_spi.c gd32f10x_libopt.h
  group TFSDK/Framework
    ../TFSDK/framework/: tf_delay.c
    ../TFSDK/framework/os/: tf_os.c tf_os_event.c tf_os_pool.c tf_os_timer.c
  group TFSDK/Lib
    ../TFSDK/lib/: heap_4.c heap_4.h
  group USER
    ../USER/: uart_and_dma.c uart_and_dma.h
    ../USER/TOOL/: tf_tool.c tf_tool.h
    ../USER/TASK/: tf_usr_event_task.c tf_usr_event_task.h tf_usr_time_task.c tf_usr_time_task.h
    ../USER/MODULE/KEY/: key.c key.h key_event.c key_event.h tf_key_list.h
    ../USER/MODULE/module_ws2812/: module_ws2812.c module_ws2812.h module_ws2812_effect.c module_ws2812_effect.h module_ws2812_status.c module_ws2812_status.h
    ../USER/MODULE/MOTO/: module_moto.c module_moto.h module_moto_hall.c module_moto_hall.h module_moto_business.c module_moto_business.h module_moto_sync.c module_moto_sync.h
    ../USER/MODULE/module_modbus/: tf_485_master.c tf_485_master.h tf_485.c tf_485.h tf_485_txq.c tf_485_txq.h tf_485_device_common.c tf_485_device_common.h tf_485_xm7828.c tf_485_xm7828.h tf_485_xm8189.c tf_485_xm8189.h tf_485_xm8537.c tf_485_xm8537.h tf_485_xm9505.c tf_485_xm9505.h tf_485_ac.c tf_485_ac.h
    ../USER/LIB/: modbus_rtu.c modbus_rtu.h ringbuf.c ringbuf.h
  group Core
    ../Core/: gd32f10x_it.c gd32f10x_it.h gd32f10x_libopt.h main.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDERR:ITM 1.1.0
