# Keil uVision project xj_jc.uvprojx, settings and files
target XJ (5060960::V5.06 update 7 (build 960)::D:\MyProg\MDK\ARM\ARM_Compiler_5.06u7)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: xj_jc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F10X_HD
  c include: ..\CMSIS;..\Core;..\GD32F10X\Include;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: system_gd32f10x.c gd32f10x.h system_gd32f10x.h
  group Startup
    ../CMSIS/GD/: startup_gd32f10x_hd.s
  group GD32F10X
    ../GD32F10X/Source/: gd32f10x_gpio.c gd32f10x_rcu.c gd32f10x_usart.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_exti.c gd32f10x_dma.c gd32f10x_misc.c gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_i2c.c gd32f10x_pmu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_wwdgt.c
  group USER/APP
    ../USER/APP/: app_status.c app_status.h app_fault.c app_fault.h app_events.h ws2812_app.c ws2812_app.h
  group USER/APP/tasks
    ../USER/APP/tasks/: app_event_task.c app_event_task.h app_timer_task.c app_timer_task.h
  group USER/BOARD
    ../USER/BOARD/: board_time.c board.c board.h board_time.h
  group USER/COMM/iec104
    ../USER/COMM/iec104/: iec104_server.c iec104_server.h
  group USER/COMM/iec104/app
    ../USER/COMM/iec104/app/: iec104_app.c iec104_app.h iec104_dispatch.c iec104_dispatch.h
  group USER/COMM/iec104/core
    ../USER/COMM/iec104/core/: iec104_apci.c iec104_apci.h iec104_asdu.c iec104_asdu.h iec104_session.c iec104_session.h iec104_txq.c iec104_txq.h
  group USER/COMM/iec104/port
    ../USER/COMM/iec104/port/: iec104_port.h iec104_port_gd32.c iec104_port_gd32.h
  group USER/COMM/link
    ../USER/COMM/link/: com_link.c com_link.h
  group USER/COMM/modbus
    ../USER/COMM/modbus/: modbus_rtu.c modbus_rtu.h modbus_master.c modbus_master.h modbus_txq.c modbus_txq.h modbus_config.h modbus_port.c modbus_port.h modbus_devices.c modbus_devices.h
  group USER/COMM/modbus/devices
    ../USER/COMM/modbus/devices/: modbus_wanrong.c modbus_wanrong.h modbus_mt80.c modbus_mt80.h modbus_weather.c modbus_weather.h modbus_common.c modbus_common.h modbus_xm8537.c modbus_xm8537.h modbus_ac.c modbus_ac.h
  group USER/COMMON
    ../USER/COMMON/: heap_4.c heap_4.h ringbuf.c ringbuf.h circular_index.c circular_index.h
  group USER/CONTROL/key
    ../USER/CONTROL/key/: key_input.c key_input.h key_event.c key_event.h key_list.h
  group USER/CONTROL/output
    ../USER/CONTROL/output/: aux_output.c aux_output.h
  group USER/CONTROL/motor
    ../USER/CONTROL/motor/: motor_driver.c motor_driver.h motor_control.c motor_control.h
  group USER/CONTROL/ws2812
    ../USER/CONTROL/ws2812/driver/: ws2812_driver.c ws2812_driver.h
    ../USER/CONTROL/ws2812/effects/: ws2812_basic.c ws2812_basic.h ws2812_mechanical.c ws2812_mechanical.h
    ../USER/CONTROL/ws2812/: ws2812_frame.c ws2812_frame.h ws2812_types.h
  group USER/DEBUG
    ../USER/DEBUG/: debug_console.c debug_console.h debug_log.h
  group USER/OS
    ../USER/OS/: os.c os_event.c os_pool.c os_timer.c os.h os_event.h os_internal.h os_pool.h os_timer.h
  group Core
    ../Core/: gd32f10x_it.c gd32f10x_it.h gd32f10x_libopt.h main.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDERR:ITM 1.1.0
