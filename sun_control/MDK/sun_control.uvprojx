# Keil uVision project sun_control.uvprojx, settings and files
target WET (5060960::V5.06 update 7 (build 960)::D:\MyProg\MDK\ARM\ARM_Compiler_5.06u7)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sun_control +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F10X_HD
  c include: ..\ThirdParty\GD32F10x\CMSIS;..\Platform\Interrupts;..\ThirdParty\GD32F10x\StandardPeripheralLibrary\Include;..\ThirdParty\FreeRTOS\Kernel\include;..\ThirdParty\FreeRTOS\Kernel\portable\RVDS\ARM_CM3;..\Application\Runtime;..\Platform\Board;..\Platform\Communication;..\Application\Communication;..\Libraries\RingBuffer;..\Libraries\Modbus;..\ThirdParty\SEGGER_RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group ThirdParty/GD32F10x/CMSIS
    ../ThirdParty/GD32F10x/CMSIS/: system_gd32f10x.c gd32f10x.h system_gd32f10x.h
  group ThirdParty/GD32F10x/CMSIS/GD
    ../ThirdParty/GD32F10x/CMSIS/GD/: startup_gd32f10x_hd.s
  group ThirdParty/GD32F10x/StandardPeripheralLibrary/Source
    ../ThirdParty/GD32F10x/StandardPeripheralLibrary/Source/: gd32f10x_gpio.c gd32f10x_rcu.c gd32f10x_usart.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_exti.c gd32f10x_dma.c gd32f10x_misc.c gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_i2c.c gd32f10x_pmu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_wwdgt.c
  group ThirdParty/FreeRTOS/Kernel
    ../ThirdParty/FreeRTOS/Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group ThirdParty/FreeRTOS/Kernel/portable/MemMang
    ../ThirdParty/FreeRTOS/Kernel/portable/MemMang/: heap_4.c
  group ThirdParty/FreeRTOS/Kernel/Headers
    ../ThirdParty/FreeRTOS/Kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group ThirdParty/FreeRTOS/Kernel/portable/RVDS/ARM_CM3
    ../ThirdParty/FreeRTOS/Kernel/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group Platform/Interrupts
    ../Platform/Interrupts/: gd32f10x_it.c
  group Application/Startup
    ../Application/Startup/: main.c
  group Application/Runtime
    ../Application/Runtime/: FreeRTOSConfig.h
  group Application/Runtime
    ../Application/Runtime/: freertos_hooks.c task_scheduler.c task_scheduler.h
  group Platform/Board
    ../Platform/Board/: board_config.c board_config.h
  group ThirdParty/SEGGER_RTT
    ../ThirdParty/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group Application/Communication
    ../Application/Communication/: comm_receive.c comm_receive.h comm_dispatch.c comm_message.h comm_dispatch.h
  group Libraries/RingBuffer
    ../Libraries/RingBuffer/: ringbuf.c ringbuf.h
  group Platform/Communication
    ../Platform/Communication/: uart_transport.c uart_transport.h
  group Libraries/Modbus
    ../Libraries/Modbus/: modbus_crc.c modbus_crc.h
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDERR:ITM 1.1.0
